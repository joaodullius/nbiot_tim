## build_nrf9160dk_nrf9160ns/spm/Kconfig/Kconfig.soc.arch
```kconfig
osource "C:/Nordic/nrf/v1.4.0/zephyr/soc/$(ARCH)/Kconfig"
osource "C:/Nordic/nrf/v1.4.0/zephyr/soc/$(ARCH)/*/Kconfig"
```
